Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HE080F_INT-EN.ifc
Time: 2025-08-05T18:35:48+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2191767_1
Port_2191767_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HE_INT-EN:HE080F, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HE_INT-EN:HE080F:2191767
In: F00
Type - Material: Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Body Radius: 109.5 mm; Connection Diameter: 80 mm; Diameter: 219 mm; Dist A: 44.45 mm; Dist B: 3 mm; Dist C: 17 mm; Dist D: 40.85 mm; Drain1 Visibility: yes; Drain2 Visibility: no; End: no; End Distance: 74 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HE_INT-EN; Geometry Radius: 43.8 mm; Handle Offset: 182 mm; H Total: 772 mm; Radius A: 100 mm; Radius B: 69 mm; Rings: no; Rings Distance: 124.5 mm; Rings Height: 436 mm; Rings Offset: 32 mm; Ring Visibility: yes; With Flanges: yes
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 80 mm; Connection Outer Diameter: 88.9 mm; H: 677 mm; h1: 623 mm; L: 370 mm; LF: 470 mm; Use Nominal Diameter: yes
Type - General - Annual Maintenance: Drain dirt from unit
Type - Identity Data - Article Description: Particle and dirt separator - Steel - Flange DN80 - High-Flow; Article Type: HE080F; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Steel - Flange DN80 - High-Flow; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811002933; Manufacturer: Spirotech; Manufacturer Art. No.: HE080F; Manufacturer URL: https://www.spirotech.com/8717811002933; MEPcontent Class: SEPARATOR_DIRT; Model: HE080F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: HE080F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Brass Yellow: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.045 m3/s; K Coefficient: 0; Pressure Stage: PN16
Type - Mechanical - Flow - Kv: 0.045 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HE080F; sets with these values: 2
Other - Connector Offset: 235 mm; Connector Offset Total: 470 mm; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HE_INT-EN: HE080F; Type: HE080F; Type Id: 2191731
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 80 mm; Minimum Size: 80 mm; Volume: 0.0279648 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
